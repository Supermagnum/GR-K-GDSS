options:
  parameters:
    author: gr-k-gdss
    category: '[KGDSS]'
    comment: RX IQ from LinHT daemon via ZMQ SUB. Requires gnuradio-zeromq. Extend with gr-sleipnir / gr-opus per docs/LINHT_INTEGRATION.md
    description: Minimal keyed GDSS RX from ZMQ at 500 ksps (demo keys).
    generate_options: no_gui
    id: rx_kgdss_linht
    output_language: python
    title: KGDSS LinHT-style ZMQ RX stub
  states: {}

blocks:
- name: linht_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: demo_key_hex
  id: variable
  parameters:
    value: '"0102030405060708090a0b0c0d0e0f101112131415161718191a1b1c1d1e1f20"'
  states: {}
- name: demo_nonce_hex
  id: variable
  parameters:
    value: '"000102030405060708090a0b"'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '"ipc:///tmp/linht_rx"'
    key: '""'
    timeout: '100'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    maximumitems: '0'
    type: complex
    samples_per_second: linht_rate
  states: {}
- name: kgdss_despreader_cc_0
  id: kgdss_despreader_cc
  parameters:
    chacha_key: demo_key_hex
    chacha_nonce: demo_nonce_hex
    chips_per_symbol: '256'
    correlation_threshold: '0.7'
    sequence_length: '256'
    timing_error_tolerance: '2'
    seed: '1'
    variance: '1.0'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}

connections:
- [zeromq_sub_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', kgdss_despreader_cc_0, '0']
- [kgdss_despreader_cc_0, '0', blocks_null_sink_0, '0']
- [kgdss_despreader_cc_0, '1', blocks_null_sink_1, '0']
- [kgdss_despreader_cc_0, '2', blocks_null_sink_2, '0']

metadata:
  file_format: 1
  grc_version: '3.10'
