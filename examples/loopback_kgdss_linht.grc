options:
  parameters:
    author: gr-k-gdss
    category: '[KGDSS]'
    comment: 'ZMQ loopback: spreader PUB on tcp://127.0.0.1:17101, SUB before despreader. Requires gnuradio-zeromq. See docs/LINHT_INTEGRATION.md'
    description: Keyed GDSS ZMQ loopback at 500 ksps (AWGN). ChaCha key/nonce are HKDF gdss_masking + gdss_nonce("loopback-test-001") from test secret bytes(range(32)); replace for real use. See generated loopback_kgdss_linht.py for correlation tap.
    generate_options: no_gui
    id: loopback_kgdss_linht
    output_language: python
    title: KGDSS LinHT-style ZMQ loopback
  states: {}

blocks:
- name: linht_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: demo_key_hex
  id: variable
  parameters:
    comment: derive_session_keys(bytes(range(32)))["gdss_masking"] as hex
    value: '"273687e5511c6254b013c2e1ca4aedc60031cc91d57a1dd848af65875f5aa8c6"'
  states: {}
- name: demo_nonce_hex
  id: variable
  parameters:
    comment: gdss_nonce("loopback-test-001", 0) as hex
    value: '"49d0ab480000000000000000"'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    amp: '1.0'
    comment: One complex symbol into spreader
    type: complex
    vlen: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    maximumitems: '0'
    type: complex
    samples_per_second: linht_rate
  states: {}
- name: kgdss_spreader_cc_0
  id: kgdss_spreader_cc
  parameters:
    chacha_key: demo_key_hex
    chacha_nonce: demo_nonce_hex
    chips_per_symbol: '256'
    seed: '1'
    sequence_length: '256'
    variance: '1.0'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://127.0.0.1:17101"'
    comment: PUB bind; daemon or SUB peer connects here
    key: '""'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://127.0.0.1:17101"'
    comment: SUB connect to same port as PUB (same host loopback)
    key: '""'
    timeout: '100'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amplitude: '0.02'
    comment: Complex AWGN
    noise_type: analog.GR_GAUSSIAN
    sample_rate: linht_rate
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: kgdss_despreader_cc_0
  id: kgdss_despreader_cc
  parameters:
    chacha_key: demo_key_hex
    chacha_nonce: demo_nonce_hex
    chips_per_symbol: '256'
    correlation_threshold: '0.7'
    sequence_length: '256'
    timing_error_tolerance: '2'
    seed: '1'
    variance: '1.0'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    comment: Despread symbols
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    comment: Lock status
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    comment: SNR estimate
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', kgdss_spreader_cc_0, '0']
- [kgdss_spreader_cc_0, '0', zeromq_pub_sink_0, '0']
- [zeromq_sub_source_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', kgdss_despreader_cc_0, '0']
- [kgdss_despreader_cc_0, '0', blocks_null_sink_0, '0']
- [kgdss_despreader_cc_0, '1', blocks_null_sink_1, '0']
- [kgdss_despreader_cc_0, '2', blocks_null_sink_2, '0']

metadata:
  file_format: 1
  grc_version: '3.10'
