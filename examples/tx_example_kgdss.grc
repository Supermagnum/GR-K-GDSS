options:
  parameters:
    author: gr-k-gdss
    copyright: Copyright 2024
    description: Keyed GDSS TX example. Audio from mic -> Codec2 -> ECIES encrypt -> SOQPSK mod -> Keyed GDSS Spreader -> SDR sink. Replace Null Sink with osmocom Sink or UHD Sink for hardware output.
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: tx_example_kgdss
    output_language: python
    title: Keyed GDSS TX Example
  states: {}

blocks:
- name: callsigns
  id: variable
  parameters:
    comment: ECIES recipient callsigns (comma-separated). Keys are looked up from kernel keyring (callsign:CALLSIGN) or from key_store_path JSON when set.
    value: '""'
  states: {}
- name: key_store_path
  id: variable
  parameters:
    comment: 'Optional. Leave empty to use kernel keyring: add recipient public keys with keyctl add user "callsign:W1ABC" "$(cat pubkey.pem)" or CallsignKeyStore.add_public_key. Or set path to JSON file for file-based store (see gr-linux-crypto docs).'
    value: '""'
  states: {}
- name: keyring_id
  id: variable
  parameters:
    comment: Kernel keyring key ID for GDSS key (from store_session_keys)
    value: '1'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    comment: Sample rate for Codec2 (e.g. 8000)
    value: '8000'
  states: {}
- name: session_id
  id: variable
  parameters:
    comment: GDSS session ID (must match RX)
    value: '1'
  states: {}
- name: tx_seq
  id: variable
  parameters:
    comment: GDSS TX sequence (increment per session)
    value: '0'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    comment: Microphone input, mono, for Codec2
    samp_rate: '48000'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    comment: Convert float audio to short for Codec2
    scale: '32768'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    comment: Replace with SDR hardware sink (e.g. osmocom Sink, UHD Sink) for real transmission. This is a placeholder so the flowgraph runs without hardware.
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: Unpack bytes to bits for SOQPSK modulator
    k: '8'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    comment: Convert Codec2 48-byte frames to byte stream for ECIES
    num_items: '48'
    type: byte
  states: {}
- name: brainpool_ecies_multi_encrypt_0
  id: brainpool_ecies_multi_encrypt
  parameters:
    callsigns: callsigns
    comment: Encrypt Codec2 bitstream with Brainpool ECIES. gr-linux-crypto reads recipient public keys from kernel keyring (callsign:CALLSIGN) when key_store_path empty, or from JSON file. See gr-linux-crypto docs.
    curve: '"brainpoolP256r1"'
    kdf_info: '"gr-linux-crypto-ecies-v1"'
    key_store_path: key_store_path
  states: {}
- name: kgdss_key_injector_0
  id: kgdss_key_injector
  parameters:
    comment: Injects GDSS key and nonce from keyring; connect key_out to spreader set_key
    keyring_id: keyring_id
    session_id: session_id
    shared_secret_hex: '"0000000000000000000000000000000000000000000000000000000000000000"'
    tx_seq: tx_seq
  states: {}
- name: kgdss_spreader_cc_0
  id: kgdss_spreader_cc
  parameters:
    chacha_key: '""'
    chacha_nonce: '""'
    chips_per_symbol: '256'
    comment: Keyed GDSS spreader; key from key_injector via set_key message
    seed: '0'
    sequence_length: '256'
    variance: '1.0'
  states: {}
- name: linux_crypto_nitrokey_interface_0
  id: linux_crypto_nitrokey_interface
  parameters:
    auto_repeat: 'False'
    comment: |-
      Kernel source can also be used.
      Please read: https://github.com/Supermagnum/gr-linux-crypto?tab=readme-ov-file#how-to-get-gnupg-key-id
    slot: '0'
  states: {}
- name: qradiolink_ldpc_encoder_0
  id: qradiolink_ldpc_encoder
  parameters:
    alist_file: '"/usr/share/gnuradio/fec/ldpc/n_0100_k_0042_gap_02.alist"'
    block_length: '576'
    code_rate: 1/2
    code_selection_mode: Auto-select by Parameters
    custom_block_length: '576'
    custom_code_rate: '0.5'
  states: {}
- name: qradiolink_mod_soqpsk_0
  id: qradiolink_mod_soqpsk
  parameters:
    carrier_freq: '0'
    comment: SOQPSK modulator (requires gr-qradiolink)
    filter_width: '10000'
    mode: '1'
    samp_rate: '250000'
    sps: '10'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Resample 48 kHz to 8 kHz for Codec2
    decim: '6'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: vocoder_codec2_encode_sp_0
  id: vocoder_codec2_encode_sp
  parameters:
    comment: |-
      Codec2 audio encoder (MODE_2400 outputs 48 bytes per frame)
      Other codecs can also be used.
    mode: codec2.MODE_2400
  states: {}

connections:
- [audio_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_short_0, '0', vocoder_codec2_encode_sp_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', qradiolink_mod_soqpsk_0, '0']
- [blocks_vector_to_stream_0, '0', qradiolink_ldpc_encoder_0, '0']
- [brainpool_ecies_multi_encrypt_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [kgdss_key_injector_0, set_key, kgdss_spreader_cc_0, set_key]
- [kgdss_spreader_cc_0, '0', blocks_null_sink_0, '0']
- [linux_crypto_nitrokey_interface_0, '0', brainpool_ecies_multi_encrypt_0, '1']
- [qradiolink_ldpc_encoder_0, '0', brainpool_ecies_multi_encrypt_0, '0']
- [qradiolink_mod_soqpsk_0, '0', kgdss_spreader_cc_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_short_0, '0']
- [vocoder_codec2_encode_sp_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1032-gab049f6e
